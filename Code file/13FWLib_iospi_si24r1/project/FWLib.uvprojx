# Keil uVision project FWLib.uvprojx, settings and files
target STM32F103C8T6_EVM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FWLib +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\user;..\libraries\CMSIS;..\libraries\STM32F10x_StdPeriph_Driver\inc;..\user\MOTOR;..\user\USART;..\user\WS2812;..\user\OLED;..\user\SYSTICK;..\user\EEPROM;..\user\KEY;..\user\SI24R1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../libraries/CMSIS/armstartup/: startup_stm32f10x_md.s
  group CMSIS
    ../libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../user/: main.c stm32f10x_it.c
    ../user/MOTOR/: bsp_motor.c
    ../user/USART/: bsp_usart.c
    ../user/WS2812/: bsp_ws2812.c
    ../user/OLED/: bsp_oled.c
    ../user/SYSTICK/: bsp_systick.c
    ../user/EEPROM/: bsp_eeprom_iic.c
    ../user/KEY/: bsp_key.c
    ../user/SI24R1/: bsp_si24r1.c
  group DOC
    ../doc/: README.txt
